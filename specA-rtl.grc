<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>multiSDR</value></param>
<param><key>author</key><value>Mark Busby &lt;mark@BusbyCreations.com&gt;</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Multiple SDRs, multiple demodulators, multiple output paths</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>MultiSDR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audioRate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1e6*center_freq_</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq_</value></param>
<param><key>value</key><value>462.5625</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:1,0,1,2</value></param>
<param><key>label</key><value>Center Frequency [MHz]</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>70</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq_rxAM</value></param>
<param><key>value</key><value>1e6*channel_freq_rxAM_</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel_freq_rxAM_</value></param>
<param><key>value</key><value>center_freq_</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:2,0</value></param>
<param><key>label</key><value>AM Channel Frequency [MHz]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>center_freq_ - (samp_rate / 2e6)</value></param>
<param><key>step</key><value>0.025</value></param>
<param><key>stop</key><value>center_freq_ + (samp_rate / 2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq_rxFM_1</value></param>
<param><key>value</key><value>1e6*channel_freq_rxFM_1_</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel_freq_rxFM_1_</value></param>
<param><key>value</key><value>center_freq_</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:3,0</value></param>
<param><key>label</key><value>FM1 Channel Frequency [MHz]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>center_freq_ - (samp_rate / 2e6)</value></param>
<param><key>step</key><value>0.025</value></param>
<param><key>stop</key><value>center_freq_ + (samp_rate / 2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq_rxFM_2</value></param>
<param><key>value</key><value>1e6*channel_freq_rxFM_2_</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel_freq_rxFM_2_</value></param>
<param><key>value</key><value>center_freq_</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:4,0</value></param>
<param><key>label</key><value>FM2 Channel Frequency [MHz]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>center_freq_ - (samp_rate / 2e6)</value></param>
<param><key>step</key><value>0.025</value></param>
<param><key>stop</key><value>center_freq_ + (samp_rate / 2e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filterDecimation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filterWidth</value></param>
<param><key>value</key><value>1000*filterWidth_</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>filterWidth_</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>tabWidget0@1:0,0</value></param>
<param><key>label</key><value>WBFM Filter Width [kHz]</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>inputGain_</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:0,0,1,2</value></param>
<param><key>label</key><value>Gain [dB]</value></param>
<param><key>min_len</key><value>2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>mute_rxAM_</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:2,1</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>mute_rxFM_1_</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:3,1</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>mute_rxFM_2_</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>tabWidget0@0:4,1</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>outGain</value></param>
<param><key>value</key><value>outGain_</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>outGain_</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>tabWidget0@2:0,0</value></param>
<param><key>label</key><value>Output Gain [dB]</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resamplerDecimation</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sdrGain</value></param>
<param><key>value</key><value>inputGain_</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>audioRate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_mute_xx</key>
<param><key>id</key><value>blocks_mute_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mute</key><value>mute_rxAM_</value></param>
</block>
<block>
<key>blocks_mute_xx</key>
<param><key>id</key><value>blocks_mute_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mute</key><value>mute_rxFM_1_</value></param>
</block>
<block>
<key>blocks_mute_xx</key>
<param><key>id</key><value>blocks_mute_xx_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mute</key><value>mute_rxFM_2_</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>C:\Users\mobusby\Desktop\rxAM.wav</value></param>
<param><key>samp_rate</key><value>audioRate</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>C:\Users\mobusby\Desktop\rxNBFM_1.wav</value></param>
<param><key>samp_rate</key><value>audioRate</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>C:\Users\mobusby\Desktop\rxNBFM_2.wav</value></param>
<param><key>samp_rate</key><value>audioRate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>0.5</value></param>
<param><key>ymin</key><value>-0.5</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rxAM_3</key>
<param><key>id</key><value>rxAM_3_0</value></param>
<param><key>rxAM_channelFreq</key><value>channel_freq_rxAM</value></param>
<param><key>rxAM_freq</key><value>center_freq</value></param>
<param><key>rxAM_gain</key><value>outGain</value></param>
<param><key>rxAM_sampleRate</key><value>samp_rate</value></param>
<param><key>rxAM_audioRate</key><value>48e3</value></param>
</block>
<block>
<key>rxNBFM</key>
<param><key>id</key><value>rxNBFM_0</value></param>
<param><key>rxNBFM_channelFreq</key><value>channel_freq_rxFM_1</value></param>
<param><key>rxNBFM_freq</key><value>center_freq</value></param>
<param><key>rxNBFM_gain</key><value>1</value></param>
<param><key>rxNBFM_sampleRate</key><value>samp_rate</value></param>
<param><key>rxNBFM_audioRate</key><value>audioRate</value></param>
</block>
<block>
<key>rxNBFM</key>
<param><key>id</key><value>rxNBFM_0_0</value></param>
<param><key>rxNBFM_channelFreq</key><value>channel_freq_rxFM_2</value></param>
<param><key>rxNBFM_freq</key><value>center_freq</value></param>
<param><key>rxNBFM_gain</key><value>1</value></param>
<param><key>rxNBFM_sampleRate</key><value>samp_rate</value></param>
<param><key>rxNBFM_audioRate</key><value>audioRate</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabWidget0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label0</key><value>Input</value></param>
<param><key>label1</key><value>Processing</value></param>
<param><key>label2</key><value>Output</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_mute_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_mute_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_mute_xx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>rxAM_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>rxNBFM_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>rxNBFM_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxAM_3_0</source_block_id><sink_block_id>blocks_mute_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxAM_3_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxNBFM_0</source_block_id><sink_block_id>blocks_mute_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxNBFM_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxNBFM_0_0</source_block_id><sink_block_id>blocks_mute_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxNBFM_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
