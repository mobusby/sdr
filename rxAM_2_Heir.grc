<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rxAM_2</value></param>
<param><key>author</key><value>Mark Busby</value></param>
<param><key>description</key><value>Receive AM PTT ssignals</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AM Receiver 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxAM_channelWidth</value></param>
<param><key>value</key><value>5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxAM_filterDecimation</value></param>
<param><key>value</key><value>int(rxAM_sampleRate/rxAM_channelWidth/10)</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>rxAM_filterDecimation</value></param>
<param><key>audio_pass</key><value>rxAM_channelWidth</value></param>
<param><key>audio_stop</key><value>rxAM_channelWidth * 1.6</value></param>
<param><key>chan_rate</key><value>rxAM_sampleRate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>rxAM_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Turn quadrature rate into audio rate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Turn sampleRate into quadrature rate</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>100</value></param>
<param><key>interp</key><value>int(10*rxAM_audioRate/rxAM_channelWidth)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxAM_audioRate</value></param>
<param><key>label</key><value>Output Audio Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxAM_freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>270.1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxAM_freqOffset</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxAM_gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rxAM_sampleRate</value></param>
<param><key>label</key><value>Input Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
